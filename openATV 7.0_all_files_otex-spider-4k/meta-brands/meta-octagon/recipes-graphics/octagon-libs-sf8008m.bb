SRCDATE = "20190917"

require octagon-libs.inc

SRC_URI[md5sum] = "a7c0297f94ea5639c2352679eb296d3d"
SRC_URI[sha256sum] = "98eed4595403b9a4a7e3b023a264c92015f74e865413291e778b80ae16e7e7fc"
