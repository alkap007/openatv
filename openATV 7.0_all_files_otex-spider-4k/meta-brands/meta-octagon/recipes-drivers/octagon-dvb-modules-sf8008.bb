KV = "4.4.176"
SRCDATE = "20210402"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "89d1c8a97dc4dddb61138b7969c34306"
SRC_URI[sha256sum] = "d82765017b2eac87237238af423717144b7dbfda5859f81a4eb3d5098fc569cf"

